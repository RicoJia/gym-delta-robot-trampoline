Commit message: ball and robot have been configured

File: urdf/soccerball.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link baseLink: mass 10.0 -> 50.0; geometry collision sphere radius=0.5; visual mesh filename=soccerball.obj scale=1 1 1
